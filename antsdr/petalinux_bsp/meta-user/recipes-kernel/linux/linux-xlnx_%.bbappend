SRC_URI += "file://user_2020-05-21-19-38-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

